# Keil uVision project SinOne_Sxx_xx.uvproj, settings and files
target SinOne (MCS-51)
  device: SC95R605P48R SC95Rxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x1FFF) CLOCK(32000000)
  output: SinOne_Sxx_xx_V +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Drivers\Lib\c;.\Drivers\Lib\H;.\Drivers\Lib\IAP_Lib;.\Drivers\Lib\TouchKey_lib;.\Drivers\Physical;.\Drivers\Protocol;.\Softwares\Application;.\Softwares\Basic;.\Softwares\ModuleLogic
  link misc: REMOVEUNUSED
  group SinOneLib
    ./: STARTUP.A51
    ./Drivers/Lib/c/: Multiplication_Division.c IAP_Init.c Uart_Init.c SSI0_Init.c SSIX_Init.c
    ./Drivers/Lib/IAP_Lib/: SC95FXX1XB_IAP_L_lib_V1.2.0.LIB
    ./Drivers/Lib/TouchKey_lib/: S_TouchKeyCFG.C SC95R605_HighSensitive_lib_T1LowPower_L_V2.0.0.LIB
  group Physical
    ./Drivers/Physical/: adc.c gpio.c i2c.c bsp_io_i2c.c I2cBus.c spi.c tim.c usart.c Basic_Function.c IO.h
  group Protocol
    ./Drivers/Protocol/: BeepMgr.c LEDsMgr.c Key_SinOne.c FingerPrint.c MFC_WS1850.c LCD_HFG12864.c RTC_PCF8563.c Flash.c EEPROM.c
  group ModuleLogic
    ./Softwares/ModuleLogic/: AppUnlock.c Battery.c HallSlide.c KeyScan.c Log.c Motor.c ISR.c LCD.c FP.c MFC.c RTC.c
  group Application
    ./Softwares/Application/: GUI.c GUI_Function.c LowPower.c main.c Project.h
  group Basic
    ./Softwares/Basic/: global_variable.c Voice_Menu.c Font_Menu.c Font.c StdTypes.h
